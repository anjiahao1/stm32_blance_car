# Keil uVision project BH-F103.uvprojx, settings and files
target Led (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 流水灯 +hex
  c flags: Optim=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\led;..\..\User\oled;..\..\User\spi1;..\..\User\nvic;..\..\User\delay;..\..\User\SYSTEM\sys;..\..\User\SysTick;..\..\User\mup6050;..\..\User\dmp;..\..\User\contral;..\..\User\EXIT;..\..\User\key;..\..\User\encode;..\..\User\pwm;..\..\User\wifi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/Led/: bsp_led.c
    ../../User/delay/: delay.c
    ../../User/nvic/: nvic.c
    ../../User/oled/: oled.c
    ../../User/spi1/: spi1.c
    ../../User/SYSTEM/sys/: sys.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/mup6050/: mpu6050.c
    ../../User/contral/: contral.c
    ../../User/EXIT/: bsp_exit.c
    ../../User/encode/: encode.c
    ../../User/key/: bsp_key.c
    ../../User/pwm/: pwm.c
    ../../User/wifi/: bsp_esp8266.c
  group DOC
    ../../Doc/: readme.txt
  group DMP
    ../../User/dmp/: inv_mpu.c inv_mpu_dmp_motion_driver.c
